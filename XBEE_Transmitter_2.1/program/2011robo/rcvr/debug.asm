 	LDI R16,50
	ADD R16,R16
 	LDI R16,-50
	ADD R16,R16
 	LDI R16,100
	ADD R16,R16
 	LDI R16,-100
	ADD R16,R16
 	LDI R16,100
 	LDI R17,-50
	ADD R16,R17
 	LDI R16,50
 	LDI R17,-100
	ADD R16,R17
 	LDI R16,200
	ADD R16,R16

RJMP	INIT

;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;;

;	LDI		RDATA	,'w'
;	RJMP	USART_Tx

DEBUG:

	CALL	RCVDATA
	
	LDI		RWREG	,0B10000000
	OUT		PORTD	,RWREG

	MOV		RWREG	,RDATA
	SWAP	RWREG
	ANDI	RWREG	,0x0f
	OUT		PORTC	,RWREG
	MOV		RWREG	,RDATA
	ANDI	RWREG	,0x03
	BST		RDATA		,6
	BLD		RWREG	,4
	BST		RDATA		,7
	BLD		RWREG	,5
	OUT		PORTB	,RWREG
USART_Tx:
	LDS		RWREG	,UCSR0A
	SBRS	RWREG	,UDRE0
	RJMP	USART_Tx	 ;���M�ޯ̧�󂫑ҋ@
;
	STS		UDR0,RDATA

;	RJMP	USART_Tx
	RJMP	DEBUG